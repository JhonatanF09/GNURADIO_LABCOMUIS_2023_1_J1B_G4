options:
  parameters:
    author: UIS
    generate_options: qt_gui
    id: LAB_2
    output_language: python
    title: PARTE A
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitd señal TX
    start: '0'
    step: 100u
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecunecia Potadora
    start: 50M
    step: 1M
    stop: 2.2G
    value: 50M
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200k
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
