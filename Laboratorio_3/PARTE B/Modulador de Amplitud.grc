options:
  parameters:
    author: Jhonatan Franco_Jhonatan Valest_J1B_G4
    generate_options: qt_gui
    id: Modulador_de_Amplitud
    output_language: python
    title: Modulador_de_Amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la portadora (Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '8'
    value: '1'
  states: {}
- name: Audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia de mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: '1000'
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente ka
    start: '0'
    step: '0.01'
    stop: '8'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/32
  states: {}
- name: CalculoPotenciaJ1B_0
  id: CalculoPotenciaJ1B
  parameters:
    l_vect: '1024'
  states: {}
- name: Envolvente_Compleja_J1B_G4_0
  id: Envolvente_Compleja_J1B_G4
  parameters:
    Ac: Ac
    ka: '1'
  states: {state: disabled}
- name: Envolvente_Compleja_SSB_J1B_G4_0
  id: Envolvente_Compleja_SSB_J1B_G4
  parameters:
    Ac: Ac
    K: k
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Audio_rate
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Compleja_J1B_G4_0, '0', blocks_complex_to_real_0, '0']
- [Envolvente_Compleja_J1B_G4_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_J1B_G4_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Compleja_J1B_G4_0, '0', uhd_usrp_sink_0, '0']
- [Envolvente_Compleja_SSB_J1B_G4_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_SSB_J1B_G4_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Compleja_SSB_J1B_G4_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaJ1B_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_J1B_G4_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_SSB_J1B_G4_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', CalculoPotenciaJ1B_0, '0']
- [rational_resampler_xxx_0, '0', Envolvente_Compleja_J1B_G4_0, '0']
- [rational_resampler_xxx_0, '0', Envolvente_Compleja_SSB_J1B_G4_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
