options:
  parameters:
    author: Jhonatan Franco_Jhonatan Valest_J1B_G4
    generate_options: qt_gui
    id: CALCULO_DE_POTENCIA
    output_language: python
    title: Potencia_Seno
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: CalculoPotenciaJ1B_0
  id: CalculoPotenciaJ1B
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', CalculoPotenciaJ1B_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
